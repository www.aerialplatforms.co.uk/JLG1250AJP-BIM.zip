Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-05-03T14:30:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 03 14:30:15 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{E8B246EF-D582-4E17-A941-8E568CE938E9}\ifc * Database version: 5507 * Database creation date: Thu May 03 14:29:54 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 03 14:29:55 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 03 14:29:55 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 m
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 m; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 m

# IfcTransportElement: Trailer Transport Position_(Platform Rotation 70°), 1001160110_1250AJP:Trailer Transport Position_(Platform Rotation 70°):6157479
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Plastic_Blue, JLG_Plastic_Green, JLG_Paint_Black, JLG_Plastic_Yellow, JLG_Steel, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_White, JLG_Paint_Orange, JLG_Paint_Beige, JLG_Plastic_Red, JLG_Rubber_Black, JLG_Paint_Silver Grey
Type - Constraints - Aa: -3.2 deg; AEa: -0.46 deg; E: 0.05 m; E1: -0.12 m; Ja: -55 deg; Jib Rotation: 155 deg; P230: yes; P450: yes; Reach: 0
Type - Data - Auxiliary Power: 12v DC; Axle Oscillation: 0.20 m (8 ft 0 in); Diesel Engine: Deutz TCD 2.9L4 55.4kW (74.2 hp); Drive Speed: 5.23 km/h (3.25 mph); Fuel Tank Capacity: 117 L (31 gal); Gradeability: 45%; Horizontal Outreach (restricted): 16.21 m (53 ft 2 in); Horizontal Outreach (un restricted): 19.25 m (63 ft 2 in); Hydraulic Tank Capacity: 202 L (53.3 gal); Jib – Overall Length: 2.44 m (8 ft 0 in ); Jib Range of Articulation: 130° Vertical (+75°/ -55°); Machine weight (ANSI): 19,958 kg (44,000 lbs); Machine weight (CE): 19,958 kg (40,000 lbs); Max Ground Bearing Pressure (ANSI): 7.03 kg/cm2 (100 psi ); Max Ground Bearing Pressure (CE): 7.03 kg/cm2 (100 psi ); Platform Capacity restricted (ANSI/CE): 450 Kg (1000 lbs); Platform Capacity restricted (CE): 450 Kg (1000 lbs); Platform Capacity Unrestricted (ANSI/CE): 230 Kg (500 lbs); Platform Capacity Unrestricted (CE): 230 Kg (500 lbs); Platform Height (restricted): 38.30m (125 ft 8 in); Platform Height (un restricted): 38.30 m (155 ft 8 in); Platform Rotator (Hydraulic): 180 degree; Platform Size: 0.91 m x 2.44 m (3 ft 0 in x 8 ft 0 in); Swing: 360 degree Continuous; Turning Radius – Inside (Axles Extended): 2.44 m (8 ft 0 in); Turning Radius – Inside (Axles Retracted): 4.39 m(14 ft 5 in); Turning Radius – Outside (Axles Extended): 5.89 m (19 ft 4 in); Turning Radius – Outside (Axles Retracted): 6.86 m (22 ft 6 in); Tyres: 445/50D710 Foam Filled
Type - Dimensions - Aa1: 176.8 deg; AEa1: 179.54 deg; Ha: -3.2 deg; Ha1: 176.8 deg; Ja1: 125 deg; JHa: 0.46 deg; JHa1: 180.46 deg; PHa: 55 deg; PHa1: 235 deg
Type - General - Articulating Jib: 2.44 m (8 ft 0 in) articulating jib; Hydraulic Platform Rotator: 180 Degrees; Platform Side Entry: 0.91 m x 2.44 m (3 ft 0 in x 8 ft 0 in); Tilt Alarm/Indicator Light: 5 degree tilt alarm and indicator light
Type - Identity Data - Model: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Trailer Transport Position_(Platform Rotation 70°)
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001160110_1250AJP; NBSDescription: Ultra Series Boom Lifts; NBSNote: n/a; NBSObjectName: JLG 1250AJP_Ultra Series boom lifts; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001160110_1250AJP; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 1250 AJP; ModelReference: JLG - Ultra Series Boom Lifts; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Ultra Series Boom Lifts; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 m; P2: no; P4: no
Dimensions - Area: 1803.89 m2; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa: 180 deg; Swing_Angle: 0 deg; Turning radius_Extended: no; Turning radius_Retracted: no; Volume: 13.0301 m3; WE: 0.05 m; Working Area: no
Identity Data - Mark: 139
Other - Family: 1001160110_1250AJP: Trailer Transport Position_(Platform Rotation 70°); Family and Type: 1001160110_1250AJP: Trailer Transport Position_(Platform Rotation 70°); Type: 1001160110_1250AJP: Trailer Transport Position_(Platform Rotation 70°); Type Id: 1001160110_1250AJP: Trailer Transport Position_(Platform Rotation 70°); WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: New Construction
